V1 0 1 1
L1 1 2 0.1
C 2 0 0.1
I1 2 0 1
R 2 3 4
C 3 0 0.1
I2 3 0 1
L2 3 4 0.1
V2 0 4 1
